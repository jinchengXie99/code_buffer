# Keil uVision project FOC_Fortior.uvproj, settings and files
target FU68XX_FOC (MCS-51)
  device: FU6812 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: FOC_Fortior +hex
  c flags: Optimize=5 SizeSpeed=1
  c include: ..\Library\FU68xx_Hardware_Driver\Include;..\User\Include
  link misc: REMOVEUNUSED
  group Apllication
    ../User/Source/Application/: main.c Interrupt.c AddFunction.c
    ../User/Include/: Customer.h Parameter.h
  group UserFiles
    ../User/Source/UserFiles/: UserMain.c UserInterrupt.c UserAddFunc.c UserFrame.c UserDryer.c UserCalculate.c UserSignal.c UserFlash.c UserUART.c
    ../User/Include/: UserDefine.h UserGlobal.h
  group Function
    ../User/Source/Function/: FocControl.c FocControlFunction.c BEMFDetect.c FOCTailDect.c RPD.c RSDDetect.c KeyScan.c LED.c Flash.c
  group Hardware
    ../User/Source/Hardware/: AMPInit.c DriverInit.c EXTIInit.c SPIInit.c TimerInit.c ADCInit.c CMPInit.c GPIOInit.c MDUInit.c PIInit.c UARTInit.c
  group FU68XX_Hardware_Driver
    ../Library/FU68xx_Hardware_Driver/Source/: FU68xx_2_System.c FU68xx_2_DMA.c Fu68xx_2_MotorContorl.LIB
